# Keil uVision project Project.uvprojx, settings and files
target STM32F030R8-Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030R8-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F030x8, PWM1_3_DEV
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\MY_LIB;..\..\..\MY_LIB\arch_define;..\..\..\MY_LIB\arch_define\hal;..\..\..\MY_LIB\arch_define\driver;..\..\..\MY_LIB\arch_define\ap;..\..\..\MY_LIB\arch_driver\hal;..\..\..\MY_LIB\arch_driver\driver;..\..\..\MY_LIB\arch_driver\ap;..\..\..\MY_LIB\extra
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f0xx_it.c main.c
  group ARCH/Driver
    ../../../MY_LIB/arch_driver/hal/: pwm_driver.c
    ../../../MY_LIB/arch_driver/driver/: breathing_led_driver.c
  group MY_LIB/API
    ../../../MY_LIB/: system_initialization.c uart_printf.c pwm1_3.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c
    ./../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c
    ././../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.1.0
